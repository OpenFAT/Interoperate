v {xschem version=3.4.7 file_version=1.2}
N 0 -30 0 -50 {lab=Z}
C {ipin.sym} -40 0 0 0 {name=p1 lab=A}
C {opin.sym} 0 -50 0 0 {name=p2 lab=Z}
C {devices/nmos4.sym} -20 0 0 0 {name=M1 w=WN l=0.2u}
C {lab_pin.sym} 0 30 0 0 {name=l1 lab=0}
C {lab_pin.sym} 0 0 0 0 {name=l2 lab=0}
